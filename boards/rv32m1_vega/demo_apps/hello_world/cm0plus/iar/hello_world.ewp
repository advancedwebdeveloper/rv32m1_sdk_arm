# IAR project hello_world.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: RV32M1_M0 RV32M1_M0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_RV32M1_cm0plus; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ../../../../../../CMSIS/Include; ../../../../../../devices; ../..; ../../../..; ../../../../../../devices/RV32M1/drivers; ../../../../../../devices/RV32M1/utilities; ../../../../../../devices/RV32M1/utilities/io; ../../../../../../devices/RV32M1/utilities/str; ../../../../../../devices/RV32M1/utilities/log; ../../../../../../devices/RV32M1; ..
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: hello_world.out
  ILINK.IlinkIcfFile: RV32M1_cm0plus_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_RV32M1_cm0plus; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0
  ICCARM.CCOptLevel: 3
  group startup
    ../../../../../../devices/RV32M1/iar/: startup_RV32M1_cm0plus.s
    ../../../../../../devices/RV32M1/: system_RV32M1_cm0plus.c system_RV32M1_cm0plus.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/RV32M1/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_port.h fsl_common.h fsl_common.c fsl_msmc.h fsl_msmc.c fsl_clock.h fsl_clock.c
  group utilities
    ../../../../../../devices/RV32M1/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_io.c fsl_io.h fsl_log.c fsl_log.h fsl_str.c fsl_str.h
  group board
    ../: board.c board.h clock_config.c clock_config.h
    ../../: pin_mux.c pin_mux.h
  group source
    ../: hello_world.c
