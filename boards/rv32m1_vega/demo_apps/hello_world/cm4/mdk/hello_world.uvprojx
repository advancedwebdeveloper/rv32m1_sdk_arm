# Keil uVision project hello_world.uvprojx, settings and files
target hello_world Debug (ARM-ADS)
  device: RV32M1:M4 openisa
  pack: openisa.RV32M1_DFP.1.0.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: hello_world.out
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_RV32M1_cm4, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../../CMSIS/Include;../../../../../../devices;../..;../../../..;../../../../../../devices/RV32M1/drivers;../../../../../../devices/RV32M1/utilities;../../../../../../devices/RV32M1/utilities/io;../../../../../../devices/RV32M1/utilities/str;../../../../../../devices/RV32M1/utilities/log;../../../../../../devices/RV32M1;..
  asm define: DEBUG
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x8000000 size 0x10000
  scatter file: RV32M1_cm4_flash.scf
  link misc: --remove
  group startup
    ../../../../../../devices/RV32M1/arm/: startup_RV32M1_cm4.s
    ../../../../../../devices/RV32M1/: system_RV32M1_cm4.c system_RV32M1_cm4.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../devices/RV32M1/drivers/: fsl_lpuart.h fsl_lpuart.c fsl_gpio.h fsl_gpio.c fsl_port.h fsl_common.h fsl_common.c fsl_msmc.h fsl_msmc.c fsl_clock.h fsl_clock.c
  group utilities
    ../../../../../../devices/RV32M1/utilities/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_io.c fsl_io.h fsl_log.c fsl_log.h fsl_str.c fsl_str.h
  group board
    ../: board.c board.h clock_config.c clock_config.h
    ../../: pin_mux.c pin_mux.h
  group source
    ../: hello_world.c
target hello_world Release (ARM-ADS)
  device: RV32M1:M4 openisa
  pack: openisa.RV32M1_DFP.1.0.0
  cpu: CPUTYPE("Cortex-M4") FPU2
  output: hello_world.out
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_RV32M1_cm4, PRINTF_FLOAT_ENABLE=0, SCANF_FLOAT_ENABLE=0, PRINTF_ADVANCED_ENABLE=0, SCANF_ADVANCED_ENABLE=0
  c misc: as above
  c include: as above
  asm misc: --cpreproc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x8000000 size 0x10000
  scatter file: RV32M1_cm4_flash.scf
  link misc: --remove
